# Keil uVision project Sample.uvprojx, settings and files
target Sample (ARM-GNU)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sample +hex
  group source
    ./source/: SampleApp.c
    ../github/stm32/common/arm/: startup_stm32f407VG.s
    ../github/stm32/modules/CAN/src/: Can.c Can_Externals.c Can_Internals.c Can_Ram.c
    ../github/stm32/common/interrupt/src/: Interrupt.c Interrupt_VectorTable.c
  group include
    ./include/: SampleApp.h
